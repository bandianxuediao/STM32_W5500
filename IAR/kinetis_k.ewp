# IAR project kinetis_k.ewp, settings and files
configuration Debug_Ram (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256xxx10 Freescale MK40DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\Source\; ..\Source\Common\; ..\Source\App\; ..\Source\Drv\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: kinetis_k.hex
  ILINK.IlinkOutputFile: kinetis_k.out
  ILINK.IlinkIcfFile: ..\Source\Common\kinetis_k_ram_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 Freescale MK40DX256Zxxx10
  OBJCOPY.OOCOutputFile: kinetis_k_debug_flash.hex
  ILINK.IlinkIcfFile: ..\Source\Common\kinetis_k_flash_iar.icf
configuration Release_Flash (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 Freescale MK40DX256Zxxx10
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: kinetis_k_release_flash.hex
  ILINK.IlinkIcfFile: ..\Source\Common\kinetis_k_flash_iar.icf
  group App
    ../Source/App/: includes.h main.c
  group Common
    ../Source/Common/: kinetis_k_startup_iar.s kinetis_k_system.c
  group Doc
    ../: 工程模板说明.txt
  group Drv
    ../Source/Drv/: kinetis_k_led.c kinetis_k_spi_withoutfifo.c mx25L1606Drv.c
