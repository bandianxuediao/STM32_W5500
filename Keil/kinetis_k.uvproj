# Keil uVision project kinetis_k.uvproj, settings and files
target Debug_Ram (ARM-ADS)
  device: MK40DX256xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: kinetis_k_debug_ram +hex
  c flags: Optim=1
  c include: ..\Source;..\Source\Common;..\Source\Drv;..\Source\App;
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group App
    ../Source/App/: main.c includes.h
  group Drv
    ../Source/Drv/: kinetis_k_led.c kinetis_k_spi_withoutfifo.c uart.c
  group Common
    ../Source/Common/: kinetis_k_startup_keil.s kinetis_k_system.c
  group Doc
    ../: readme.txt
  group W5500
    ../Source/W5500Lib/Ethernet/W5500/: w5500.c w5500_init.c
    ../Source/W5500Lib/Ethernet/: socket.c wizchip_conf.c
target Debug_Flash (ARM-ADS)
  device: MK30DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: kinetis_k_debug_flash +hex
  c flags: Optim=1
  c misc: --C99
  c include: ..\Source;..\Source\Common;..\Source\Drv;..\Source\App;..\Source\W5500Lib\Ethernet\W5500;..\Source\W5500Lib\Ethernet
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
target Release_Flash (ARM-ADS)
  device: MK40DX256xxx10 Freescale Semiconductor
  cpu: as above
  output: kinetis_k_release_flash +hex
  c flags: Optim=4
  c include: ..\Source;..\Source\Common;..\Source\Drv;..\Source\App;
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
